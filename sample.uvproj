# Keil uVision project sample.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: sample
  c flags: Optim=2 v6Lang=1 v6LangP=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group startup_file
    ./: startup_LPC17xx.s
  group main
    ./: sample.c
  group lib_SoC_board
    ./: core_cm3.c system_LPC17xx.c
  group led
    ./led/: funct_led.c lib_led.c led.h
  group button_EINT
    ./button_EXINT/: lib_button.c button.h IRQ_button.c
  group timer
    ./timer/: lib_timer.c IRQ_timer.c timer.h
  group RIT
    ./RIT/: IRQ_RIT.c lib_RIT.c RIT.h
  group joystick
    ./joystick/: funct_joystick.c joystick.h lib_joystick.c
  group Panel
    ./Panel/: RequPan.c RequPan.h
  group Elevator
    ./Elevator/: ElevatorControl.h funct_ElevatorControl.c lib_EC.c
  group adc
    ./adc/: adc.h IRQ_adc.c lib_adc.c
  group dac
    ./dac/: lib_dac.c dac.h
  group GLCD
    ./GLCD/: AsciiLib.c AsciiLib.h GLCD.c GLCD.h HzLib.c HzLib.h
  group TouchPanel
    ./TouchPanel/: TouchPanel.c TouchPanel.h
